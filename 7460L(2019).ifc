Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-04-10T22:41:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 10 22:41:42 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{74275C39-4F07-4F0C-9502-E1A009396B87}\ifc * Database version: 5507 * Database creation date: Fri Apr 10 22:41:42 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 10 22:41:42 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 10 22:41:42 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7460L Shower faucet, 7460L(2019):7460L Shower faucet:358533
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 81.3 mm; NominalHeight: 63.4 mm; NominalWidth: 291.3 mm; Projection: 212 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 7460L(2019); ConvergoRefNr: 0087-2003-0052-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 03/04/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150095788; EN Standard: EN 1111; RSKNumber: 8351336
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/7460L; Catalog Drawing URL: http://static.oras.com/catdrw/7460L; Class: Thermostatic; Dimension Drawing URL: http://static.oras.com/dimdrw/7460L; FDV Document URL: http://www.oras.com/datasheet/7460L/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7460L; Group: Shower faucets; Manufacturer: Oras; Market: SWE; Model: 7460L Shower faucet; Name_en: 7460L Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 294 x 164 x 83 mm; Package Weight: 1.805 kg; Product Code: 7460L; Product Datasheet: http://www.oras.com/datasheet/7460L/en; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7460L; Product URL: http://static.oras.com/7460L; Type Name: 7460L Shower faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G1/2; Eco Flow At 300kPa: 0.00670979 m3/s; Flow Rate At 300kPa: 0.00953496 m3/s; Installation and Maintenance: http://static.oras.com/manual/7460L; Installation Type: Wall-mounted; Installation Width: cc150 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Litter filter(s);Non-return valve(s);Ceramic head part; Noise Class: I (ISO 3822) Oras lab.; Pressure Loss With Flow 02ls: 165000 Pa; Shower Parts: Eco flow control; Spare Parts: http://static.oras.com/sp/7460L; Temperature Adjustments: Thermostatic safety stop at 38°C;Temperature fixable
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7460L(2019); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7460L; Name: 7460L Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 220x188.6x407.2 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7460L; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7460L Shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.049303 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00151325 m3
Identity Data - Mark: 18
Mechanical - System Classification: Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 7460L(2019): 7460L Shower faucet; Family and Type: 7460L(2019): 7460L Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7460L(2019): 7460L Shower faucet; Type Id: 7460L(2019): 7460L Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
